<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Uart_9R.ewp</path>
  </project>
  <batchBuild />
</workspace>
